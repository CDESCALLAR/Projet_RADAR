# Keil uVision project MiniProjet.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: MiniProjet
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\test.sct
  group Source Group 1
    ./: main.c configuration.c GUI_SingleThread.c UDP_Socket.c
  group AW source
    ./appwizard/TestAppwizard/Source/: APPW_MainTask.c
    ./appwizard/TestAppwizard/Source/Generated/: APPWConf.c ID_SCREEN_00.c Resource.c
    ./appwizard/TestAppwizard/Source/CustomCode/: Application.c ID_SCREEN_00_Slots.c
  group AW resources
    ./appwizard/TestAppwizard/Resource/Text/: APPW_Language_0.c
    ./appwizard/TestAppwizard/Resource/Image/: DARK_Slider_Shaft_H_Left_Blue_30x16.c DARK_Slider_Shaft_H_Right_Gray_30x16.c DARK_Slider_Thumb_Down_22x22.c DARK_Slider_Thumb_Up_22x22.c DARK_Switch_Body_H_Off_55x20.c DARK_Switch_Body_H_On_55x20.c DARK_Switch_Thumb_26x26.c logo_iut.c DARK_Rotary_BG_Gray_80x80.c DARK_Rotary_Marker_Blue_16x5.c
    ./appwizard/TestAppwizard/Resource/Font/: NettoOT_32_Normal_EXT_AA4.c
    ./appwizard/TestAppwizard/Resource/Movie/: Logo_240x136.c
software components: CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.1, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, CMSIS Driver:Ethernet MAC 1.12.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DAC 1.3.0, Device:STM32Cube HAL:DMA2D 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.5, Graphics Display:STM32F746G-Discovery 1.0.2, Network:CORE 7.19.0, Network:Interface:ETH 7.19.0, Network:Socket:UDP 7.19.0, Graphics:CORE 6.32.3, Graphics:Input Device:Touchscreen 6.32.3
